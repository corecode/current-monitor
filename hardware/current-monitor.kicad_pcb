# Repository corecode/current-monitor

## KiCad design hardware/current-monitor.kicad_pcb

Parts:
C1, C5, C7, C8, C9, C11, C12, C14, C15: 0.1u; SMD-1608
C2, C6, C25, C27, C28: 2.2u 16V; SMD-2012
C3, C10, C13: 2.2u; SMD-2012
C4: 100p; SMD-1608
C16, C17, C18, C19, C20, C21, C22, C23, C24, C26: 1u; SMD-1608
D1: BAV70; SOT-23
F1: 1.1A; SMD-3216
J1: SENSE; JST-XH-2-PTH-TOP
J2: BATTERY; JST-XH-2-PTH-TOP
J3: ERC12864-1; ER-CON30HB-1
J4: USB-MICROB; USB-MICRO-B-FCI-10103594
J5: LCD_BL; ER-CON2.0-2P-SMD
J6: AUX; CONN-2x4-1.0-PTH-RIGHT-SHROUD
J7: SWD; CONN-5-2.54-1.0-PTH
L1, L2: 22u; SMD-1608
Q1, Q2: 2N2222; SOT-23-BJT
R1: 0.33; SMD-2012
R2, R5, R6, R9, R11, R14: 100k; SMD-1608
R3, R13, R18, R20, R22: 10k; SMD-1608
R4, R8, R10: 100; SMD-1608
R7, R12, R15, R21: 499; SMD-1608
R17, R19, R26, R27, R28, R29, R30: 1k; SMD-1608
R23, R24: 33; SMD-1608
R25: 120; SMD-1608
S1: POWER; SWITCH-8x8-DPDT
S2, S3: TACTILE-4; TACT-6mm
TP1: SENSE+; TESTPOINT-2.0
TP2: SENSE-; TESTPOINT-2.0
TP3: COM; TESTPOINT-2.0
TP4: FINEOFF; TESTPOINT-2.0
TP5: FINE; TESTPOINT-2.0
TP6: COARSEOFF; TESTPOINT-2.0
TP7: COARSE; TESTPOINT-2.0
TP8: VREF; TESTPOINT-2.0
U1: AP2210K-3.3; SOT-23-5
U2: MCP6V81U; SOT-23-5
U3: MCP6001U; SOT-23-5
U4: MKL27ZxxVFM4
U5, U6: NUP4114; SOT-23-6

Connections:
+3V3: C3.1, C10.1, C11.1, C12.1, C25.1, C26.1, J3.5 (R/~W), J3.6 (~RD~/E), J3.7 (DB0), J3.8 (DB1), J3.9 (DB2), J3.10 (DB3), J3.11 (DB4), J3.12 (DB5), J3.15 (VDD), J6.1, J6.3, J7.1, R4.1, U1.5 (VOUT), U4.5 (USB_VDD), U4.15 (VDD), U6.5
/AUX_USR1: J6.8, R30.2, U6.1
/AUX_USR2: J6.6, R29.2, U6.3
/BUTTON1: S2.2, U4.26 (PTC5)
/BUTTON2: S3.2, U4.27 (PTC6/CMP0_IN0)
/LCD_CLK: J3.13 (DB6/SCL), U4.30 (PTD5/ADC0_SE6b)
/LCD_DATA: J3.4 (A0), U4.28 (PTC7/CMP0_IN1)
/LCD_LED: R26.1, U4.25 (PTC4)
/LCD_MOSI: J3.14 (DB7/SI), U4.31 (PTD6/ADC0_SE7b)
/SWD_CLK: J7.3, U4.10 (SWD_CLK)
/SWD_DIO: J7.2, U4.13 (SWD_DIO)
/UART_RX: J6.4, R27.2, U6.4
/UART_TX: J6.2, R28.2, U6.6
/USB_DM: J4.2 (D-), R24.1, U5.6
/USB_DP: J4.3 (D+), R23.1, U5.1
/~LCD_CS: J3.2 (~CS1), U4.29 (PTD4)
/~LCD_RES: J3.3 (~RES), U4.32 (PTD7)
/~RESET: J7.5, U4.19 (~RESET)
BAT_SENSE: C1.1, R2.2, R3.1, U4.23 (PTC2/ADC0_SE11)
COARSE: C9.1, R22.2, U4.21 (PTB1/ADC0_SE9)
FINE: C7.1, R13.2, U4.20 (PTB0/ADC0_SE8)
unnamed: C4.1, U1.4 (BYP)
unnamed: C16.1, J3.17 (VOUT)
unnamed: C17.1, J3.18 (CAP3+)
unnamed: C17.2, C18.1, J3.19 (CAP1-)
unnamed: C18.2, J3.20 (CAP1+)
unnamed: C19.1, J3.21 (CAP2+)
unnamed: C19.2, J3.22 (CAP2-)
unnamed: C20.1, J3.23 (V1)
unnamed: C21.1, J3.24 (V2)
unnamed: C22.1, J3.25 (V3)
unnamed: C23.1, J3.26 (V4)
unnamed: C24.1, J3.27 (V5)
unnamed: F1.1, J1.1
unnamed: J2.1, S1.1B
unnamed: J4.1 (VBUS), L1.1, U5.5
unnamed: J5.2, Q1.C
unnamed: Q1.B, Q2.C, R26.2
unnamed: Q1.E, Q2.B, R25.1
unnamed: R5.2, R6.2, R7.1, R9.1, TP4.TP
unnamed: R8.1, R9.2, U2.1 (+)
unnamed: R10.1, R11.2, U2.3 (-)
unnamed: R11.1, R12.2
unnamed: R12.1, R13.1, TP5.TP, U2.4
unnamed: R14.2, R15.1, R18.1, TP6.TP
unnamed: R17.1, R18.2, U3.1 (+)
unnamed: R19.1, R20.2, U3.3 (-)
unnamed: R20.1, R21.2
unnamed: R21.1, R22.1, TP7.TP, U3.4
unnamed: R23.2, U4.3 (USB0_DP)
unnamed: R24.2, U4.4 (USB0_DM)
unnamed: R27.1, U4.11 (PTA1)
unnamed: R28.1, U4.12 (PTA2)
unnamed: R29.1, U4.18 (PTA19)
unnamed: R30.1, U4.17 (PTA18)
SENSE+: F1.2, R1.1, R8.2, R17.2, TP1.TP
SENSE-: J1.2, R1.2, R10.2, R19.2, TP2.TP
VREF: C15.1, R5.1, R6.1, R14.1, TP8.TP, U4.9 (PTE30/ADC0_SE23)

Notes on the sheet:
9uV offset V RTI 9mV offset V RTO
150uV offset V RTI 1.5mV offset V RTO
1.19V
11mV
494R impedance
Sense Input + Shunt
Fine Sense
Coarse Sense
Debug Connector
MCU
Power
Buttons
Display
Display Backlight
USB
6mV
497R impedance
Serial and Aux
I_LED =~~ 0.67/R25

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
Board: 2 copper layers, 100.0 x 100.0 mm, 92 parts (0 on the bottom side), 64 nets.

Other parts of the board:
HOLE-M3, HOLE-M3#2, HOLE-M3#3, HOLE-M3#4, HOLE-M3#5: VAL**; HOLE-M3-COND

## KiCad design current-monitor.kicad_pcb

Parts:
C1, C8, C9: 2.2u 16V; SMD-2012
C2: 2.2u; SMD-2012
C3: 100p; SMD-1608
C4, C5, C6, C7, C10, C11, C12: 0.1u; SMD-1608
J1: SENSE; TERM-2-2.5
J2: BATTERY; JST-XH-2-PTH-TOP
J3: LCD5110; CONN-2x4-1.0-PTH-SHROUD
J4: UART; CONN-4-2.54-0.8-PTH
J5: SWD; CONN-4-2.54-0.8-PTH
J6: JTAG; CONN-2x5-1.27-SMT
Q1: MUN5314DW1; SOT-23-6
R1: 0.33; SMD-2012
R2, R6, R25: 100; SMD-1608
R3, R7, R17: 1M; SMD-1608
R4, R11: 6.81k; SMD-1608
R5, R12: 536; SMD-1608
R8, R16, R19, R20: 499; SMD-1608
R9, R13, R14: 1k; SMD-1608
R10, R15, R18, R21, R22: 10k; SMD-1608
S1, S2: TACTILE-4; TACT-6mm
S3: slide-SPDT; SLIDE-1P2T-SIDE-PTH
TP1: FINEOFF; TESTPOINT-2.0
TP2: FINE; TESTPOINT-2.0
TP3: VREF; TESTPOINT-2.0
TP4: COM; TESTPOINT-2.0
TP5: COARSEOFF; TESTPOINT-2.0
TP6: COARSE; TESTPOINT-2.0
TP7: SENSE+; TESTPOINT-2.0
TP8: SENSE-; TESTPOINT-2.0
U1: AP2210K-3.3; SOT-23-5
U2: MKL03Z8VFK4; qfn-24-4x4
U3: MCP6V71U; SOT-23-5
U4: MCP6031; SOT-23-5

Connections:
+3V3: C2.1, C5.1, J3.1, J4.1, J5.1, J6.1 (VTref), R25.1, U1.5 (VOUT), U2.3
/BUTTON1: S1.2, U2.1
/BUTTON2: S2.2, U2.2
/LCD_DATA: J3.5, U2.7
/MISO: U2.8
/MOSI: J3.6, U2.11
/SCLK: J3.7, U2.12
/SD_DET: U2.18
/SWD_CLK: J5.3, J6.4 (SWDCLK/TCK), U2.22
/SWD_DIO: J5.2, J6.2 (SWDIO/TMS), U2.24
/UART_RX: J4.2, J6.8 (TDI), R20.1
/UART_TX: J4.3, J6.6 (SWO/TDO), R19.1
/~LCD_CS: J3.3, U2.9
/~LCD_LED: Q1.2, U2.10
/~RESET: J3.4, J6.10 (~RESET), U2.23
/~SD_CS: U2.17
COARSE: C12.1, R22.2, U2.20
FINE: C11.1, R21.2, U2.16
unnamed: C3.1, U1.4 (BYP)
unnamed: C10.1, R17.2, R18.1, U2.13
unnamed: J2.1, S3.COM
unnamed: J3.8, R13.2
unnamed: Q1.3, R13.1
unnamed: Q1.5, Q1.6
unnamed: R2.1, R3.2, U3.1 (+)
unnamed: R3.1, R4.1, R5.2, TP1.TP
unnamed: R6.1, R7.2, U3.3 (-)
unnamed: R7.1, R8.2
unnamed: R10.1, R11.1, R12.2, TP5.TP
unnamed: R9.1, R10.2, U4.1 (+)
unnamed: R14.1, R15.2, U4.3 (-)
unnamed: R15.1, R16.2
unnamed: R16.1, R22.1, TP6.TP, U4.4
unnamed: R19.2, U2.5
unnamed: R20.2, U2.6
unnamed: R8.1, R21.1, TP2.TP, U3.4
SENSE+: J1.1, R1.1, R2.2, R9.2, TP7.TP
SENSE-: J1.2, R1.2, R6.2, R14.2, TP8.TP
VREF: C6.1, R4.2, R11.2, TP3.TP, U2.14

Notes on the sheet:
8uV offset V RTI 80mV offset V RTO
150uV offset V RTI 1.5mV offset V RTO
1.19V
87mV
497R impedance
Sense Input + Shunt
Fine Sense
Coarse Sense
Debug Connectors
MCU
Power
Display
Buttons

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
Board: 2 copper layers, 50.0 x 50.0 mm, 57 parts (0 on the bottom side), 39 nets.

## Code that names these connections

File firmware/board/board.h:

enum {
        PIN_UART_RX = PIN_PTA1,
        PIN_UART_TX = PIN_PTA2,
        PIN_USR1 = PIN_PTA18,
        PIN_USR2 = PIN_PTA19,
        ADC_FINE = 8,
        ADC_COARSE = 9,
        ADC_VBAT = 11,
        PIN_LCD_LED = GPIO_PTC4,
        PIN_BUTTON1 = GPIO_PTB5,
        PIN_BUTTON2 = GPIO_PTB6,
        PIN_LCD_DATA = GPIO_PTB7,
        PIN_LCD_nCS = PIN_PTD4,
        PIN_LCD_nCS_PCS = 0,
        PIN_SCLK = PIN_PTD5,
        PIN_MOSI = PIN_PTD6,
        PIN_LCD_nRES = PIN_PTD7,
        PIN_VREF = PIN_PTE30,
};

#define LCD_SPI SPI1

void board_init(void);
void lcd_led(int state);

## Commit log

2016-09-13 lowspeed current monitor
2016-09-13 improve power routing
2016-09-14 logo + silkscreen
2016-09-14 update gerber settings
2016-11-24 add part numbers - some are wrong though
2016-12-16 output readings
2017-01-14 implement display
2017-01-14 start redesign
2017-04-10 redesign for v1 r1
2017-04-10 switch datasheet
2017-04-29 BOM for schematic
2017-04-29 start firmware changes for r1
2017-04-29 add mchckrc
2017-05-04 more r1 changes
